<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00046.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="50AF7AEE-047F-4F64-9FD6-3998E01645F9">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C2FE6CFF-3238-4B4E-84F4-081055488098">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6C1B0582-0F11-45AB-8322-CA71E78ADE6F">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AF14B0A1-B2DA-4E0D-831D-E0A311BC60C4">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E98ABF65-45DD-4506-997F-3263ACB7A67B">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5912DEC8-44BF-4AC1-87EC-F301570AB7C7">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2873CA95-8AC8-4944-A8B7-C353FB92751D">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="43DE5A64-D3A5-40C5-83F9-419F2ABCCD8B">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="83E029A1-15B1-409A-8F6F-3A31515502E4">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="09B6B197-012B-4F23-933B-C947A77495DD">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4CA4EB87-3BE2-4D76-82D6-843E35645231">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B4F7CE6A-E9DB-4219-9DEB-CFFE706A1E05">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="04B520D4-D927-444D-9022-5A9E65C059AB">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="222091D2-A166-4584-B725-8557D1AD1172">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F9D1743F-40FA-4D58-9DEF-9EDDF6C371EC">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="751EB8E7-F355-41D4-81AD-E27844B5C0A3">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="24837FBB-418E-439D-9151-F9EC49DA39EF">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CCBB8B7E-EF45-4278-825B-1388F0DC6EF9">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="BCF786C8-06E6-4DCE-9735-DCB4E915D6E4">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5FC4B499-0C62-4EB2-8F1B-2683C72E287C">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1017E0D-3E80-4A9C-9A94-E3784D8EFC78">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="85899EEB-97A0-4416-A8F7-D04B5879D916">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="61EE227E-4E06-4CDC-A626-45E5F8B9B904">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="59A3378D-B85E-4EB5-AA71-CD9634D681C3">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E36A7CB4-C6B2-46C0-86C4-B7C90D0049F4">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="878E03EA-0198-4CB7-B82F-74D9CD8083DA">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB74DF76-DF32-43F2-9E20-2EC2901D360E">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="94C3351B-0464-4762-9E62-E80E3C3E274A">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1869475E-8692-4F7B-B72E-9CEAE3DB975A">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F67AE006-7BE7-4E4D-B9B6-9D1982E4ECD9">
      <SHORT-NAME>VectorAutosarExplorerGeneratedObjects</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6DC275C-3B50-4E8B-A2AB-BF6D04B6FA00">
          <SHORT-NAME>SYSTEM</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="22EE04AE-3B97-4E7C-ACD1-D4C348CB4E9C">
          <SHORT-NAME>Induction_Training_BB</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="872C6F99-84DC-45EF-8429-A9E93E4E9DB5">
          <SHORT-NAME>ECU_INSTANCES</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C1C7F9D8-1C37-4123-A2FB-429700C4ABA0">
          <SHORT-NAME>FRAME</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="08F6B6CB-18A5-4D7A-9498-36638B14F7DB">
          <SHORT-NAME>PDUS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6822FD0E-D2CB-4424-8D7E-B0A299E0EA3F">
          <SHORT-NAME>I_SIGNALS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="734B673D-6FA9-4C46-92DB-07B89339ED41">
          <SHORT-NAME>BASE_TYPES</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F485DC16-04F3-4B36-AC8E-B6955752474C">
          <SHORT-NAME>SYSTEM_SIGNALS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ACC60E23-04C0-4273-9FC0-E49B15266F51">
          <SHORT-NAME>PDU_GROUP</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="880B8877-D337-495D-BA88-8C4209D3CF0A">
          <SHORT-NAME>COMPUMETHODS</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>